# Keil uVision project UART_DMA.uvproj, settings and files
target NUC970 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA910CRAXBG Toshiba
  cpu: IRAM(0xF8002000-0xF800FFFF) IROM(0x0-0x3FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: UART_DMA +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Driver\Include
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\Scipt\nuc970.sct
  link misc: --entry 0
  group src
    ./: main.c
  group Library
    ./Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_nuc970.c uart.c startup_NUC970.s sys_nuc970.s
